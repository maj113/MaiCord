// MPEG audio Layer III decoding; see maicord/media/mp3_decoder.h. The tables
// are ISO/IEC 11172-3 Annex B and 13818-3 (and the MPEG-2.5 bands its FhG
// extension uses); the Huffman codes are multi-level lookup tables. The
// transforms run 8 lanes wide: the IMDCT over subbands, the synthesis DCT and
// window over time slots.
#include "maicord/media/mp3_decoder.h"
#include "maicord/sys/simd.hpp"
#include <string.h>

typedef __m256 V;
// Synthesis input (36 slots, padded to whole 8-slot groups) and DCT row widths.
enum {
    kSlots = 40,
    kRows = 15 + kSlots
};

static const uint16_t kRates[3] = {44100, 48000, 32000};
// Kilobits per second / 8, MPEG-1 and MPEG-2/2.5.
static const uint8_t kBitrates[2][15] = {{0, 4, 5, 6, 7, 8, 10, 12, 14, 16, 20, 24, 28, 32, 40},
                                         {0, 1, 2, 3, 4, 5, 6, 7, 8, 10, 12, 14, 16, 18, 20}};
// blendv masks: kLeading + 8 - n selects the first n lanes.
static const float kLeading[16] = {-0.0f, -0.0f, -0.0f, -0.0f, -0.0f, -0.0f, -0.0f, -0.0f};
// Sign bits on the odd lanes (from kOddLanes + 1: the even ones).
static const float kOddLanes[9] = {0.0f, -0.0f, 0.0f, -0.0f, 0.0f, -0.0f, 0.0f, -0.0f, 0.0f};
// Huffman tables: entries are (bits << 8) | (x << 4) | y, bits the codeword's
// (past any subtable index) plus one sign bit per nonzero value, or
// -((offset << 4) | bits) for a subtable of `bits` index bits. kHuffmanTables:
// offset and root bits of tables 1, 2, 3, 5-13, 15, 16 and 24; kTableSelect:
// that table + 1 | linbits << 4. kCount1: count1 table A, (bits << 4) | vwxy,
// sign bits included. Long-block IMDCT windows and tails have their
// transform's signs folded in.
// clang-format off
static const uint8_t kCount1[64] = {
    155, 175, 157, 158, 151, 133, 121, 121, 118, 118, 115, 115, 122, 122, 124, 124, 82, 82, 82, 82, 81, 81,
    81, 81, 84, 84, 84, 84, 88, 88, 88, 88, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16,
    16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16};
static const int16_t kHuffman[2406] = {
    1297, 1025, 784, 784, 256, 256, 256, 256, -513, 1810, 1825, 1568, 1297, 1297, 1297, 1297, 1025, 1025,
    1025, 1025, 1040, 1040, 1040, 1040, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256,
    256, 256, 256, 802, 514, -513, 1810, 1825, 1568, 1040, 1040, 1040, 1040, 1041, 1041, 1041, 1041, 1041,
    1041, 1041, 1041, 769, 769, 769, 769, 769, 769, 769, 769, 512, 512, 512, 512, 512, 512, 512, 512, 802,
    514, -132, 1297, 1025, 1040, 256, 256, 256, 256, -385, 1586, 1329, 1329, 1555, 1283, 1328, 1570, 1298,
    1298, 1313, 1313, 1026, 1026, 1056, 1056, 819, 803, -514, -577, 1811, 1841, 1826, 1538, 1554, 1554,
    1569, 1569, 1312, 1312, 1025, 1025, 1025, 1025, 1041, 1041, 1041, 1041, 1041, 1041, 1041, 1041, 1040,
    1040, 1040, 1040, 768, 768, 768, 768, 1075, 771, 803, 803, 818, 560, -516, -835, -963, -1090, 1825,
    -1153, 1553, 1553, 1025, 1025, 1025, 1025, 1040, 1040, 1040, 1040, 256, 256, 256, 256, 256, 256, 256,
    256, 256, 256, 256, 256, 256, 256, 256, 256, -769, -801, 1589, 1604, 1573, 1618, 1301, 1301, 1361, 1361,
    1285, 1588, 1104, 1104, 1603, 1587, 853, 837, 852, 851, 1316, 1346, 1044, 1044, 1089, 1089, 832, 832,
    1028, 1315, 1330, 1027, 1043, 1043, 1073, 1073, 816, 1058, 786, 786, 514, 544, -261, -868, 1554, 1569,
    1041, 1041, 1041, 1041, 1025, 1025, 1040, 1040, 512, 512, 512, 512, -770, 1875, -833, 1829, 1874, 1541,
    1557, 1557, 1617, 1617, 1844, 1859, 1616, 1843, 1572, 1572, 1602, 1602, 1556, 1556, 1345, 1345, 1345,
    1345, 1284, 1284, 1344, 1344, 1571, 1571, 1586, 1586, 1109, 1108, 837, 837, 821, 836, 1555, 1585, 1283,
    1328, 1058, 1058, 1058, 1058, 770, 770, 770, 770, 800, 800, 800, 800, -1027, -1154, -1217, -1250, -1313,
    -1345, 2068, 2113, 2083, 2098, 1811, 1811, 1841, 1841, 1795, 1840, 1826, 1826, 1538, 1538, 1554, 1554,
    1554, 1554, 1569, 1569, 1569, 1569, 1312, 1312, 1312, 1312, 1297, 1297, 1297, 1297, 1297, 1297, 1297,
    1297, 1025, 1025, 1025, 1025, 1025, 1025, 1025, 1025, 1040, 1040, 1040, 1040, 1040, 1040, 1040, 1040,
    768, 768, 768, 768, 768, 768, 768, 768, 1365, 1349, 1077, 1077, 1107, 1107, 1364, 1029, 1092, 1061,
    1106, 1045, 849, 820, 835, 835, 848, 772, 804, 834, 819, 576, -1028, -1412, -1668, -1923, -2051, -2178,
    -2241, -2273, 2066, 2081, 1794, 1824, 1553, 1553, 1553, 1553, 1025, 1025, 1025, 1025, 1025, 1025, 1025,
    1025, 1040, 1040, 1040, 1040, 1040, 1040, 1040, 1040, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256,
    256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256,
    256, -1281, -1313, -1345, 1607, 1652, 1622, 1637, 1591, 1651, 1606, -1377, 1635, 1319, 1319, 1394, 1394,
    887, 871, 886, 855, 885, 870, 853, 852, 1636, 1287, 1136, 1136, 1378, 1378, 1605, 1589, 1030, 1030,
    1619, 1604, 1047, 1047, 1047, 1047, 1137, 1137, 1137, 1137, 1334, 1334, 1318, 1318, 1573, 1618, 1301,
    1301, 1361, 1361, 1588, 1603, 1046, 1046, 1121, 1121, 864, 864, 1029, 1104, 1316, 1346, 1331, 1028,
    1044, 1044, 1089, 1089, 832, 1059, 1074, 771, 787, 817, 560, 802, -515, -1027, -1187, -1347, -1507,
    -1633, -1666, 1825, 1554, 1554, 1538, 1568, 1297, 1297, 1297, 1297, 1025, 1025, 1025, 1025, 1040, 1040,
    1040, 1040, 512, 512, 512, 512, 512, 512, 512, 512, -642, -707, -834, -897, -930, 1319, 1394, -993,
    1143, 1127, 1142, 1141, 1126, 1126, 1095, 1095, 1140, 1140, 1367, 1365, 1110, 1125, 823, 823, 883, 838,
    1093, 1108, 1077, 1107, 868, 519, 1137, 1137, 1303, 1136, 1334, 1379, 1120, -1153, 836, 805, -1313,
    1301, 1122, 1122, 1318, 1030, 1046, 1046, 850, 517, 1121, 1121, 1361, 1332, 1104, -1473, 1316, 1346,
    835, 819, 1300, 1345, 1028, 1088, 1059, 1059, 1074, 1074, 787, 817, 771, 816, 802, 802, -1027, -1187,
    -1314, -1379, -1507, -1633, -1666, -1730, -1793, -1825, -1858, -1921, 2099, 2113, 2083, 2098, -1953,
    1840, 1811, 1811, 1841, 1841, 1826, 1826, 1554, 1554, 1554, 1554, 1569, 1569, 1569, 1569, 1538, 1538,
    1568, 1568, 1024, 1024, 1024, 1024, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1025, 1025, 1025,
    1025, 1025, 1025, 1025, 1025, 1040, 1040, 1040, 1040, 1040, 1040, 1040, 1040, -1153, 1398, 1367, 1397,
    1382, 1351, 1396, 1381, 887, 871, 1110, 1110, 1079, 1079, 1395, 1365, 1063, 1063, 1138, 1094, 1124,
    1047, 1137, 1137, 1031, 1136, 1078, 1078, 1123, 1123, 1093, 1093, 1108, 1108, 1092, 1092, 1030, 1029,
    806, 866, 865, 865, 1046, 864, 1077, 1107, 1061, 1106, 789, 849, 820, 835, 848, 772, 804, 804, 834, 788,
    576, 515, -1028, -4388, -5220, -5732, -6020, -6275, -6404, -6659, -6786, -6850, -6913, -6945, 2066,
    2081, 1794, 1824, 1553, 1553, 1553, 1553, 1281, 1281, 1281, 1281, 1040, 1040, 1040, 1040, 1040, 1040,
    1040, 1040, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256,
    256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, -1284, -2436, -2724, -2980, -3235,
    -3363, -3491, -3619, -3747, -3875, -4003, -4130, -4194, -4257, -4289, -4322, -1540, -1826, -1891, -2017,
    -2050, -2113, -2145, -2177, -2209, -2242, -2306, 1783, 1754, -2369, -2401, 1647, -1793, 1789, 1517,
    1517, 1279, 1279, 1279, 1279, 1263, 1263, 1263, 1263, 1247, 1247, 1247, 1247, 1022, 1020, 1262, 1231,
    1246, 1215, 1275, 1275, 1230, 1230, 1244, 1244, 1455, 1513, 1004, 989, 1274, 1229, 958, 958, 1003, 927,
    1017, 1002, 957, 987, 911, 1016, 972, 972, 1198, 1182, 910, 910, 1151, 1150, 941, 956, 971, 1014, 1768,
    1631, 1693, 1753, 1781, 1767, 1708, 1723, 1615, 1780, -2689, 1779, 1343, 1343, 1677, 1752, 970, 998,
    1327, 1327, 1522, 1522, 1646, 1692, 1039, 1039, 1737, 1630, 1451, 1451, 1661, 1751, 1358, 1358, 1736,
    1750, 1342, 1342, 1465, 1465, 1691, 1706, 1055, 1055, 1055, 1055, 1265, 1265, 1265, 1265, 1008, 1008,
    1466, 1509, 1508, 1420, 1389, 1507, 1250, 1250, 1326, 1038, 1054, 1054, 1249, 1249, 1248, 1373, 1493,
    1404, 1479, 1357, 1419, 1464, 1492, 1434, 1449, 1388, 1222, 1222, 1085, 1085, 1491, 1403, 1069, 1069,
    1234, 1234, 1053, 1053, 1207, 1207, 1372, 1477, 1433, 1402, 1219, 1219, 1447, 1431, 1099, 1099, 977,
    977, 977, 977, 781, 976, 1162, 1192, 1100, 1220, 1131, 1206, 828, 812, 962, 859, 1205, 1161, 796, 796,
    -4642, -4706, -4770, -4834, -4898, -4962, -5026, 1714, 1563, 1713, -5089, -5121, -5153, -5185, 1578,
    1698, 961, 961, 1176, 780, 704, 704, 1204, 1130, 1190, 1145, 827, 827, 947, 947, 1160, 1114, 811, 811,
    1189, 1129, 932, 932, 1144, 1159, 916, 916, 1143, 1142, 523, 688, 918, 842, 826, 931, 857, 917, 1562,
    1697, -5473, 1440, -5505, 1683, -5537, -5569, 1577, 1682, -5601, 1592, 1667, -5633, -5665, -5697, 522,
    872, 902, 841, 825, 856, 901, 871, 855, 885, 870, 839, 884, 854, 869, 883, 1305, 1305, 1425, 1425, 1289,
    1424, 1608, 1668, 1650, -5985, 1320, 1320, 1410, 1410, 1304, 1304, 838, 868, 1591, 1575, 1303, 1303,
    1393, 1393, 1621, 1287, 1392, 1590, 1635, 1605, 1620, 1574, 1634, 1589, 1153, 1153, 1032, 1152, 1302,
    1377, 1030, 1120, 1619, 1604, 1317, 1317, 1362, 1362, 1029, 1029, 1045, 1045, 1045, 1045, 1105, 1105,
    1105, 1105, 1332, 1347, 1104, 1316, 1346, 1331, 1044, 1044, 833, 833, 772, 832, 1059, 1074, 787, 787,
    817, 515, 560, 802, -2052, -2980, -3332, -3620, -3908, -4164, -4420, -4676, -4931, -5059, -5187, -5315,
    -5442, -5507, -5634, -5699, -5826, -5890, -5954, -6018, -6081, -6113, -6146, -6210, -6273, -6305, -6337,
    -6370, -6433, -6465, -6497, -6530, 2401, -6593, 2341, 2386, 2325, 2385, -6625, 2356, 2371, 2340, 2370,
    2355, 2113, 2113, 2324, 2052, 2083, 2083, 2098, 2098, 2112, 2051, 2067, 2067, 2097, 2097, 1840, 1840,
    1826, 1826, 1826, 1826, 1810, 1810, 1810, 1810, 1825, 1825, 1825, 1825, 1538, 1538, 1538, 1538, 1568,
    1568, 1568, 1568, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297, 1297,
    1297, 1297, 1281, 1281, 1281, 1281, 1281, 1281, 1281, 1281, 1296, 1296, 1296, 1296, 1296, 1296, 1296,
    1296, 768, 768, 768, 768, 768, 768, 768, 768, 768, 768, 768, 768, 768, 768, 768, 768, -2306, -2370,
    -2434, -2498, -2561, -2593, -2625, -2657, -2689, -2721, -2753, -2785, -2817, -2849, -2881, -2914, 1279,
    1263, 1278, 1247, 1006, 1006, 1277, 1231, 1276, 1246, 1261, 1215, 1019, 1019, 1230, 1260, 989, 943,
    1018, 958, 1003, 973, 988, 927, 1017, 1002, 957, 987, 911, 1016, 972, 926, 1001, 895, 1015, 941, 986,
    956, 879, 879, 1198, 783, 1739, 1782, -3233, -3265, 1781, 1662, 1767, 1708, 1738, 1723, -3297, 1615,
    1780, 1599, 1779, 1752, 910, 1000, 863, 925, 985, 909, 1766, 1583, 1778, -3585, 1567, 1777, 1692, 1737,
    1630, 1707, 1722, 1765, 1661, 1751, 1614, 1764, 878, 752, 1676, 1736, 1598, 1645, 1750, 1763, 1691,
    1721, 1582, 1706, 1762, 1566, 1761, -3873, 1629, 1749, 526, 736, 1660, 1735, 1613, 1675, 1492, 1492,
    1720, 1690, 1705, 1644, 1734, 1597, 1491, 1491, 1490, 1490, 1581, 1293, 1309, 1309, 1403, 1403, 1463,
    1463, 1489, 1489, 1628, 1488, 1477, 1477, 1418, 1418, 1448, 1448, 1356, 1356, 1476, 1476, 1387, 1387,
    1462, 1462, 1689, 1292, 1340, 1340, 1475, 1475, 1402, 1402, 1447, 1447, 1446, 1446, 1472, 1291, 1218,
    1218, 1218, 1218, 1324, 1324, 1371, 1371, 1461, 1308, 1417, 1432, 1473, 1355, 1460, 1386, 1339, 1401,
    1203, 1203, 1431, 1416, 1323, 1370, 1202, 1202, 1445, 1307, 1201, 1201, 1200, 1385, 1430, 1354, 1444,
    1400, 1415, 1338, 1187, 1187, 1113, 1173, 1066, 1186, 1050, 1050, 1185, 1185, 1034, 1184, 1128, 1128,
    1158, 1097, 1172, 1081, 1171, 1171, 1399, 1033, 1112, 1112, 1157, 1157, 1065, 1127, 1142, 1170, 913,
    913, 1049, 912, 1096, 1156, 1111, 1141, 1080, 1155, 1126, 1095, 808, 898, 792, 897, 1140, 776, 896,
    1110, 1125, 1079, 1139, 1094, 807, 882, 868, 791, 853, 881, 775, 880, 822, 822, 867, 837, 852, 806, 866,
    790, 774, 864, 821, 821, 851, 836, 517, 592, -517, -1829, -4485, -5573, -6084, -6339, -6465, -6497,
    1553, 1553, 1281, 1281, 1040, 1040, 1040, 1040, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256, 256,
    256, 256, 256, 256, 256, -1025, -1057, -1089, -1121, 1967, -1153, -1185, 1935, 1919, 2039, 1903, 2038,
    1535, 1535, 1535, 1535, 1887, 2037, 1615, 1615, 1780, 1780, 1779, 1779, 1520, 1520, 1855, -1221, 1522,
    1522, 1522, 1522, 1007, 1022, 991, 1021, 975, 1020, 959, 1019, 1018, 927, 1017, 1016, -1730, 2014, 2025,
    -1793, 1774, 1774, 2029, 2027, 1726, 1726, 1741, 1741, 2012, 2011, 1710, 1710, 1740, 1740, 1965, 2010,
    1918, 1964, 1738, 1738, 1993, 1917, 1630, 1630, 1469, 1469, 1469, 1469, 974, 974, 1260, 1245, 1002, 985,
    1583, 1583, 1295, 1295, 1311, 1311, 1311, 1311, 1521, 1521, 1521, 1521, -2340, -2596, -2852, -3107,
    -3235, -3363, -3491, -3618, -3682, -3747, -3874, -3938, -4002, -4066, -4130, -4193, -4226, -4290, -4354,
    -4418, 1438, 1438, 1724, 1739, 1678, 1768, 1693, 1767, 1723, 1677, 1752, 1646, 1510, 1510, 1436, 1436,
    1707, 1722, 1765, 1751, 1358, 1358, 1764, 1676, 1480, 1480, 1342, 1342, 1389, 1389, 1750, 1691, 1721,
    1706, 1505, 1505, 1492, 1492, 1720, 1705, 1403, 1403, 1719, 1488, 1251, 1251, 1251, 1251, 1038, 1248,
    1373, 1493, 1404, 1479, 1357, 1419, 1434, 1388, 1478, 1341, 1372, 1477, 781, 781, 1418, 1448, 1433,
    1356, 1462, 1402, 1084, 1084, 1371, 1417, 1052, 1052, 960, 960, 1432, 1401, 994, 994, 1070, 1054, 1235,
    1069, 1234, 1233, 1083, 1083, 1431, 1416, 797, 797, 797, 797, 1220, 1131, 1219, 1191, 812, 812, 1218,
    1205, 1217, 780, 1099, 1204, 1130, 1190, 947, 947, 1114, 1189, 811, 811, 946, 795, 945, 945, 779, 944,
    1129, 1174, 1098, 1188, 1144, 1159, 931, 931, 1082, 1113, 810, 810, -4994, -5058, -5122, 1954, 1818,
    -5185, -5217, -5249, 1833, 1938, -5281, 1817, 1937, -5313, -5345, -5377, -5409, 1922, -5441, 1816, 1921,
    1664, -5473, 1847, 1907, -5505, 1831, 1906, -5537, 1543, 1559, 1559, 1173, 1128, 929, 929, 1158, 1143,
    916, 916, 1097, 1111, 871, 871, 522, 672, 825, 915, 856, 901, 886, 521, 656, 840, 900, 885, 824, 899,
    870, 808, 839, 884, 520, 854, 869, 838, 868, 853, 1649, 1649, 1648, 1846, 1891, 1861, 1876, 1830, 1634,
    1634, 1558, 1558, 1633, 1633, 1542, 1632, 1619, 1619, 1845, 1860, 1573, 1573, 1618, 1618, 1361, 1361,
    1361, 1361, 1557, 1557, 1285, 1285, 1588, 1603, 1360, 1572, 1602, 1587, 1300, 1300, 1345, 1345, 1284,
    1344, 1315, 1315, 1330, 1330, 1043, 1043, 1073, 1073, 1027, 1072, 1058, 1058, 786, 801, 514, 544, -2049,
    -2081, -2113, -2145, 2554, -2177, 2553, 2552, -2209, 2551, 2415, 2550, 2399, 2549, 2383, 2548, 2367,
    2547, 2351, 2546, 2545, -2241, -2276, -2532, 1791, 1791, 1791, 1791, 1791, 1791, 1791, 1791, -2788,
    -3076, -3331, -3459, -3587, -3715, -3844, -4099, -4228, -4484, -4739, -4867, -4995, -5122, -5186, -5250,
    -5314, -5378, -5442, -5506, -5570, -5635, -5763, -5890, -5953, -5985, -6017, -6049, -6081, -6113, -6146,
    -6209, -6241, -6274, 2385, -6337, 2340, 2370, 2355, 2324, 2369, -6369, 2339, 2354, 2067, 2067, 2097,
    2097, 2051, 2096, 2082, 2082, 1810, 1810, 1810, 1810, 1825, 1825, 1825, 1825, 1794, 1794, 1824, 1824,
    1553, 1553, 1553, 1553, 1553, 1553, 1553, 1553, 1281, 1281, 1281, 1281, 1281, 1281, 1281, 1281, 1296,
    1296, 1296, 1296, 1296, 1296, 1296, 1296, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1007, 1022,
    991, 1021, 975, 1020, 959, 1019, 943, 927, 911, 895, 799, 752, 783, 783, 783, 783, 1774, 1758, 1773,
    1742, 1772, 1757, 1726, 1771, 1741, 1756, 1710, 1770, 1725, 1755, 1740, 1694, 1769, 1709, 1754, 1724,
    1739, 1678, 1768, 1693, 1753, 1662, 1767, 1708, 1738, 1723, 1677, 1752, -3041, 1293, 1510, 1510, 1646,
    1692, 1481, 1481, 1374, 1374, 1466, 1466, 526, 736, 1509, 1509, 1707, 1661, 1495, 1495, 1508, 1508,
    1420, 1420, 1480, 1480, 1614, 1582, 1342, 1342, 1389, 1494, 1507, 1435, 1465, 1450, 1506, 1310, 1505,
    1373, 1493, 1404, 1479, 1357, 1419, 1464, 1492, 1434, 1449, 1388, 1478, 1341, 1491, 1325, 1490, 1309,
    1403, 1463, 1489, 1372, 1477, 1418, 1448, 1448, 1433, 1433, 1356, 1356, 1476, 1476, 1387, 1387, 1462,
    1462, 1488, 1292, 1340, 1340, 1475, 1402, 1447, 1324, 1474, 1371, 1461, 1308, 1417, 1417, 1432, 1432,
    1473, 1473, 1355, 1355, 1472, 1291, 1339, 1339, 1456, 1290, 1306, 1306, 1204, 1204, 1204, 1204, 1386,
    1386, 1446, 1446, 1401, 1401, 1431, 1431, 1440, 1289, 1168, 1168, 1203, 1203, 1160, 1160, 1323, 1370,
    1202, 1202, 1445, 1307, 1457, 1385, 1174, 1174, 1188, 1188, 1354, 1400, 1159, 1159, 1082, 1082, 1187,
    1187, 1113, 1173, 1066, 1186, 1185, 1128, 1158, 1143, 1097, 1172, 1081, 1171, 1112, 1157, 1065, 1127,
    1142, 1170, 1049, 1169, 1096, 1156, 1111, 1141, 1080, 1155, 1126, 1064, 1154, 1048, 1095, 1140, 1153,
    1153, 1032, 1152, 1110, 1110, 1125, 1125, 1047, 1047, 1031, 1136, 883, 883, 883, 883, 1079, 1063, 882,
    882, 838, 868, 853, 881, 822, 867, 837, 852, 806, 866, 790, 865, 774, 864, 821, 821, 851, 836, 805, 850,
    789, 789, 773, 848, 820, 835, 516, 576};
static const uint16_t kHuffmanTables[15][2] = {
    0, 3, 8, 5, 42, 5, 76, 3, 102, 5, 140, 5, 214, 4, 284, 6, 370, 6, 514, 5, 622, 6, 746, 6, 1182, 7, 1598,
    5, 2006, 7};
static const uint8_t kTableSelect[32] = {
    0, 1, 2, 3, 0, 4, 5, 6, 7, 8, 9, 10, 11, 12, 0, 13, 30, 46, 62, 78, 110, 142, 174, 222, 79, 95, 111,
    127, 143, 159, 191, 223};
static const uint8_t kLongWidths[9][22] = {
    4, 4, 4, 4, 4, 4, 6, 6, 8, 8, 10, 12, 16, 20, 24, 28, 34, 42, 50, 54, 76, 158, 4, 4, 4, 4, 4, 4, 6, 6,
    6, 8, 10, 12, 16, 18, 22, 28, 34, 40, 46, 54, 54, 192, 4, 4, 4, 4, 4, 4, 6, 6, 8, 10, 12, 16, 20, 24,
    30, 38, 46, 56, 68, 84, 102, 26, 6, 6, 6, 6, 6, 6, 8, 10, 12, 14, 16, 20, 24, 28, 32, 38, 46, 52, 60,
    68, 58, 54, 6, 6, 6, 6, 6, 6, 8, 10, 12, 14, 16, 18, 22, 26, 32, 38, 46, 54, 62, 70, 76, 36, 6, 6, 6, 6,
    6, 6, 8, 10, 12, 14, 16, 20, 24, 28, 32, 38, 46, 52, 60, 68, 58, 54, 6, 6, 6, 6, 6, 6, 8, 10, 12, 14,
    16, 20, 24, 28, 32, 38, 46, 52, 60, 68, 58, 54, 6, 6, 6, 6, 6, 6, 8, 10, 12, 14, 16, 20, 24, 28, 32, 38,
    46, 52, 60, 68, 58, 54, 12, 12, 12, 12, 12, 12, 16, 20, 24, 28, 32, 40, 48, 56, 64, 76, 90, 2, 2, 2, 2,
    2};
static const uint8_t kShortWidths[9][13] = {
    4, 4, 4, 4, 6, 8, 10, 12, 14, 18, 22, 30, 56, 4, 4, 4, 4, 6, 6, 10, 12, 14, 16, 20, 26, 66, 4, 4, 4, 4,
    6, 8, 12, 16, 20, 26, 34, 42, 12, 4, 4, 4, 6, 6, 8, 10, 14, 18, 26, 32, 42, 18, 4, 4, 4, 6, 8, 10, 12,
    14, 18, 24, 32, 44, 12, 4, 4, 4, 6, 8, 10, 12, 14, 18, 24, 30, 40, 18, 4, 4, 4, 6, 8, 10, 12, 14, 18,
    24, 30, 40, 18, 4, 4, 4, 6, 8, 10, 12, 14, 18, 24, 30, 40, 18, 8, 8, 8, 12, 16, 20, 24, 28, 36, 2, 2, 2,
    26};
static const uint8_t kPretab[22] = {
    0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 2, 2, 3, 3, 3, 2, 0};
static const uint8_t kSlen[2][16] = {
    0, 0, 0, 0, 3, 1, 1, 1, 2, 2, 2, 3, 3, 3, 4, 4, 0, 1, 2, 3, 0, 1, 2, 3, 1, 2, 3, 1, 2, 3, 2, 3};
static const uint8_t kLsfCounts[6][3][4] = {
    6, 5, 5, 5, 9, 9, 9, 9, 6, 9, 9, 9, 6, 5, 7, 3, 9, 9, 12, 6, 6, 9, 12, 6, 11, 10, 0, 0, 18, 18, 0, 0,
    15, 18, 0, 0, 7, 7, 7, 0, 12, 12, 12, 0, 6, 15, 12, 0, 6, 6, 6, 3, 12, 9, 9, 6, 6, 12, 9, 6, 8, 8, 5, 0,
    15, 12, 9, 0, 6, 18, 9, 0};
static const float kPow43[16] = {
    0, 1.0f, 2.5198421f, 4.326749f, 6.349604f, 8.54988f, 10.902723f, 13.390518f, 16.0f, 18.720755f,
    21.544348f, 24.463781f, 27.473143f, 30.56735f, 33.741993f, 36.99318f};
static const float kQuarter[4] = {
    1.0f, 1.1892071f, 1.4142135f, 1.6817929f};
static const float kIntensity[7] = {
    0, .21132487f, .36602542f, .5f, .6339746f, .7886751f, 1.0f};
static const float kAntialias[2][8] = {
    .8574929f, .881742f, .94962865f, .9833146f, .9955178f, .9991606f, .9998992f, .99999315f, -.51449573f,
    -.47173196f, -.31337744f, -.1819132f, -.09457419f, -.040965583f, -.014198569f, -.0036999746f};
static const float kCos9[8][4] = {
    .9848077f, .8660254f, .64278764f, .34202015f, .9396926f, .5f, -.17364818f, -.76604444f, .8660254f,
    6.123234e-17f, -.8660254f, -.8660254f, .76604444f, -.5f, -.9396926f, .17364818f, .64278764f, -.8660254f,
    -.34202015f, .9848077f, .5f, -1.0f, .5f, .5f, .34202015f, -.8660254f, .9848077f, -.64278764f,
    .17364818f, -.5f, .76604444f, -.9396926f};
static const float kTwiddle9[9] = {
    .5019099f, .5176381f, .55168897f, .61038727f, .70710677f, .8717234f, 1.1831008f, 1.9318516f,
    5.7368565f};
static const float kTwiddle18[18] = {
    .50047636f, .5043145f, .51213974f, .5242646f, .5411961f, .56369096f, .59284455f, .6302362f, .67817086f,
    .7400936f, .8213398f, .9305795f, 1.0828403f, 1.306563f, 1.6627548f, 2.3101132f, 3.830649f, 11.462792f};
static const float kCos6[6][6] = {
    .9914449f, .9238795f, .7933533f, .6087614f, .38268343f, .13052619f, .9238795f, .38268343f, -.38268343f,
    -.9238795f, -.9238795f, -.38268343f, .7933533f, -.38268343f, -.9914449f, -.13052619f, .9238795f,
    .6087614f, .6087614f, -.9238795f, -.13052619f, .9914449f, -.38268343f, -.7933533f, .38268343f,
    -.9238795f, .9238795f, -.38268343f, -.38268343f, .9238795f, .13052619f, -.38268343f, .6087614f,
    -.7933533f, .9238795f, -.9914449f};
static const float kShortWindow[12] = {
    .13052619f, .38268343f, .6087614f, .7933533f, .9238795f, .9914449f, .9914449f, .9238795f, .7933533f,
    .6087614f, .38268343f, .13052619f};
static const float kLongWindow[2][18] = {
    .043619387f, .13052619f, .21643962f, .3007058f, .38268343f, .4617486f, .53729963f, .6087614f, .6755902f,
    -.7372773f, -.7933533f, -.8433914f, -.8870108f, -.9238795f, -.95371693f, -.976296f, -.9914449f,
    -.99904823f, 0, 0, 0, 0, 0, 0, .13052619f, .38268343f, .6087614f, -.7933533f, -.9238795f, -.9914449f,
    -1.0f, -1.0f, -1.0f, -1.0f, -1.0f, -1.0f};
static const float kTail[3][18] = {
    -.99904823f, -.9914449f, -.976296f, -.95371693f, -.9238795f, -.8870108f, -.8433914f, -.7933533f,
    -.7372773f, -.6755902f, -.6087614f, -.53729963f, -.4617486f, -.38268343f, -.3007058f, -.21643962f,
    -.13052619f, -.043619387f, -1.0f, -1.0f, -1.0f, -1.0f, -1.0f, -1.0f, -.9914449f, -.9238795f, -.7933533f,
    -.6087614f, -.38268343f, -.13052619f, 0, 0, 0, 0, 0, 0, .9914449f, .9238795f, .7933533f, .6087614f,
    .38268343f, .13052619f, .9914449f, .9238795f, .7933533f, .6087614f, .38268343f, .13052619f, 0, 0, 0, 0,
    0, 0};
static const float kTailShort[6] = {
    .13052619f, .38268343f, .6087614f, -.7933533f, -.9238795f, -.9914449f};
static const float kDctTwiddle[31] = {
    .500603f, .50547093f, .5154473f, .5310426f, .5531039f, .582935f, .6225041f, .6748083f, .7445363f,
    .8393496f, .9725682f, 1.1694399f, 1.4841646f, 2.057781f, 3.4076085f, 10.190008f, .5024193f, .5224986f,
    .56694406f, .6468218f, .7881546f, 1.0606776f, 1.7224472f, 5.1011486f, .5097956f, .6013449f, .8999762f,
    2.5629156f, .5411961f, 1.306563f, .70710677f};
static const float kSynthesis[16][8][2] = {
    0, .00044250488f, .003250122f, .007003784f, .031082153f, .07862854f, .10031128f, .57203674f, 1.144989f,
    -.57203674f, .10031128f, -.07862854f, .031082153f, -.007003784f, .003250122f, -.00044250488f,
    -1.5258789e-5f, .00047302246f, .003326416f, .0079193115f, .030517578f, .08418274f, .090927124f,
    .6002197f, 1.1442871f, -.54382324f, .1088562f, -.07305908f, .03147888f, -.0061187744f, .0031738281f,
    -.00039672852f, -1.5258789e-5f, .0005340576f, .0033874512f, .008865356f, .029785156f, .08970642f,
    .08068848f, .6282959f, 1.1422119f, -.51560974f, .11657715f, -.06752014f, .03173828f, -.0052948f,
    .0030822754f, -.00036621094f, -1.5258789e-5f, .000579834f, .0034332275f, .009841919f, .028884888f,
    .09516907f, .06959534f, .6562195f, 1.1387634f, -.48747253f, .12347412f, -.06199646f, .031845093f,
    -.004486084f, .0029907227f, -.00032043457f, -1.5258789e-5f, .00062561035f, .0034637451f, .010848999f,
    .027801514f, .10054016f, .057617188f, .6839142f, 1.1339264f, -.45947266f, .12957764f, -.056533813f,
    .031814575f, -.0037231445f, .00289917f, -.000289917f, -1.5258789e-5f, .0006866455f, .003479004f,
    .011886597f, .026535034f, .1058197f, .044784546f, .71131897f, 1.1277466f, -.43165588f, .1348877f,
    -.051132202f, .031661987f, -.0030059814f, .0027923584f, -.0002593994f, -1.5258789e-5f, .00074768066f,
    .003479004f, .012939453f, .02508545f, .110946655f, .031082153f, .7383728f, 1.120224f, -.40408325f,
    .13945007f, -.045837402f, .03138733f, -.0023345947f, .0026855469f, -.00024414062f, -3.0517578e-5f,
    .0008087158f, .0034637451f, .014022827f, .023422241f, .11592102f, .01651001f, .7650299f, 1.1113739f,
    -.37680054f, .14326477f, -.040634155f, .03100586f, -.0016937256f, .0025787354f, -.00021362305f,
    -3.0517578e-5f, .00088500977f, .0034179688f, .01512146f, .021575928f, .12069702f, .0010681152f,
    .791214f, 1.1012115f, -.34986877f, .1463623f, -.03555298f, .030532837f, -.0010986328f, .002456665f,
    -.00019836426f, -3.0517578e-5f, .0009613037f, .0033721924f, .016235352f, .01953125f, .1252594f,
    -.0152282715f, .816864f, 1.0897827f, -.32331848f, .1487732f, -.03060913f, .029937744f, -.0005493164f,
    .0023498535f, -.00016784668f, -3.0517578e-5f, .0010375977f, .0032806396f, .017349243f, .01725769f,
    .12956238f, -.03237915f, .84194946f, 1.0771179f, -.2972107f, .15049744f, -.025817871f, .029281616f,
    -3.0517578e-5f, .002243042f, -.00015258789f, -4.5776367e-5f, .0011138916f, .0031738281f, .018463135f,
    .014801025f, .1335907f, -.050354004f, .8663635f, 1.0632172f, -.2715912f, .15159607f, -.0211792f,
    .028533936f, .00044250488f, .0021209717f, -.0001373291f, -4.5776367e-5f, .0012054443f, .0030517578f,
    .019577026f, .0121154785f, .13729858f, -.06916809f, .89009094f, 1.0481567f, -.24650574f, .15206909f,
    -.016708374f, .02772522f, .000869751f, .0020141602f, -.00012207031f, -6.1035156e-5f, .0012969971f,
    .0028839111f, .020690918f, .009231567f, .14067078f, -.088775635f, .9130554f, 1.0319366f, -.22198486f,
    .15196228f, -.012420654f, .02684021f, .0012664795f, .0019073486f, -.00010681152f, -6.1035156e-5f,
    .0013885498f, .0027008057f, .02178955f, .006134033f, .14367676f, -.10916138f, .9351959f, 1.0146179f,
    -.19805908f, .15130615f, -.00831604f, .025909424f, .0016174316f, .0017852783f, -.00010681152f,
    -7.6293945e-5f, .0014801025f, .0024871826f, .022857666f, .002822876f, .1462555f, -.13031006f,
    .95648193f, .99624634f, -.17478943f, .15011597f, -.0043945312f, .024932861f, .0019378662f, .0016937256f,
    -9.1552734e-5f};
static const float kSynthesisMiddle[8] = {
    .0015869141f, .023910522f, .14842224f, .9768524f, -.15220642f, -.0006866455f, .0022277832f,
    -7.6293945e-5f};
// clang-format on

typedef struct Reader {
    const uint8_t* data;
    uint32_t at;
} Reader;
static inline uint64_t peek(const uint8_t* data, uint32_t at) {
    uint64_t v;
    memcpy(&v, data + (at >> 3), 8);
    return __builtin_bswap64(v) << (at & 7);
}
static inline uint32_t take(Reader* r, uint32_t bits) {
    const uint32_t v = bits ? (uint32_t)(peek(r->data, r->at) >> (64 - bits)) : 0;
    r->at += bits;
    return v;
}
static inline V splat(float v) {
    return _mm256_set1_ps(v);
}
static inline V lanes(uint32_t n) {
    return _mm256_loadu_ps(kLeading + 8 - n);
}
static inline V negate(V v) {
    return _mm256_xor_ps(v, splat(-0.0f));
}

int mp3_frame_parse(const uint8_t* h, uint32_t available, Mp3Frame* out) {
    if (available < 4)
        return 4;
    if (h[0] != 0xff || (h[1] & 0xe6) != 0xe2 || ((h[1] >> 3) & 3) == 1 || (h[2] >> 4) == 15 ||
        ((h[2] >> 2) & 3) == 3 || (h[3] & 3) == 2)
        return 2;
    if (!(h[2] >> 4))
        return 3; // Free format: the header gives no frame size.
    Mp3Frame f;
    memset(&f, 0, sizeof(f));
    f.version = (h[1] >> 3) & 3;
    const uint32_t lsf = f.version != 3, mono = h[3] >> 6 == 3, crc = h[1] & 1 ? 0 : 2;
    const uint32_t side = lsf ? (mono ? 9 : 17) : (mono ? 17 : 32);
    f.rate_index = (uint8_t)(((h[2] >> 2) & 3) + (lsf ? (f.version ? 3 : 6) : 0));
    f.sample_rate = kRates[(h[2] >> 2) & 3] >> (lsf + !f.version);
    f.channels = (uint8_t)(2 - mono);
    f.samples = (uint16_t)(1152 >> lsf);
    f.mid_side = h[3] >> 6 == 1 && (h[3] & 0x20);
    f.intensity = h[3] >> 6 == 1 && (h[3] & 0x10);
    f.bytes = (lsf ? 576000u : 1152000u) * kBitrates[lsf][h[2] >> 4] / f.sample_rate + ((h[2] >> 1) & 1);
    if (f.bytes < 4 + crc + side)
        return 2;
    if (f.bytes > available)
        return 4;
    f.main_bytes = f.bytes - 4 - crc - side;
    // The side information (its CRC is not checked), from a copy padded for peek.
    uint8_t bits[40] = {0};
    memcpy(bits, h + 4 + crc, side);
    Reader r = {bits, 0};
    f.main_data_begin = take(&r, lsf ? 8 : 9);
    r.at += lsf ? f.channels : mono ? 5 : 3;
    const uint32_t scfsi = lsf ? 0 : take(&r, 4 * f.channels), count = (uint32_t)f.channels << !lsf;
    uint32_t parts = 0;
    for (uint32_t i = 0; i < count; ++i) {
        Mp3Granule* g = &f.granules[i];
        g->part2_3_bits = (uint16_t)take(&r, 12);
        g->big_values = (uint16_t)take(&r, 9);
        g->global_gain = (uint8_t)take(&r, 8);
        g->scalefac_compress = (uint16_t)take(&r, lsf ? 9 : 4);
        parts += g->part2_3_bits;
        if (g->big_values > 288)
            return 2;
        if (take(&r, 1)) {
            g->block_type = (uint8_t)take(&r, 2);
            g->mixed = (uint8_t)take(&r, 1);
            if (!g->block_type)
                return 2;
            for (uint32_t t = 0; t < 2; ++t)
                g->table[t] = (uint8_t)take(&r, 5);
            for (uint32_t w = 0; w < 3; ++w)
                g->subblock_gain[w] = (uint8_t)take(&r, 3);
        } else {
            for (uint32_t t = 0; t < 3; ++t)
                g->table[t] = (uint8_t)take(&r, 5);
            g->region0 = (uint8_t)take(&r, 4);
            g->region1 = (uint8_t)take(&r, 3);
        }
        g->preflag = (uint8_t)(lsf ? 0 : take(&r, 1));
        g->scalefac_scale = (uint8_t)take(&r, 1);
        g->count1_table = (uint8_t)take(&r, 1);
        // Second granules' long blocks may share scalefactor groups with the first.
        if (i >= f.channels && g->block_type != 2)
            g->scfsi = (uint8_t)((scfsi >> 4 * (2 * f.channels - 1 - i)) & 15);
    }
    if (parts > (f.main_bytes + f.main_data_begin) * 8)
        return 2;
    *out = f;
    return 0;
}

// One granule channel's scalefactor bands in bitstream order: the long bands,
// then the short bands window by window.
typedef struct Bands {
    float scale[40];
    uint16_t end[40], region1, region2;
    uint8_t width[40], count, longs, first_short;
} Bands;

static inline float quarter_power(int32_t q) { // 2^(q / 4)
    const int32_t e = (q >> 2) + 127;
    if (e <= 0)
        return 0;
    const uint32_t bits = (uint32_t)e << 23;
    float v;
    memcpy(&v, &bits, 4);
    return v * kQuarter[q & 3];
}

// Reads the scalefactors at r and lays out the bands. sf keeps the first
// granule's values for scfsi; limit is each band's illegal intensity position.
static void scalefactors(Reader* r, const Mp3Frame* f, const Mp3Granule* g, uint32_t intensity_right,
                         uint8_t* sf, uint8_t* limit, Bands* b) {
    const uint32_t lsf = f->version != 3, shorts = g->block_type == 2;
    const uint8_t *long_widths = kLongWidths[f->rate_index], *short_widths = kShortWidths[f->rate_index];
    b->longs = (uint8_t)(!shorts ? 22 : g->mixed ? (lsf ? 6 : 8) : 0);
    b->first_short = (uint8_t)(b->longs ? 3 : 0);
    memcpy(b->width, long_widths, b->longs);
    uint32_t n = b->longs;
    for (uint32_t sfb = b->first_short; shorts && sfb < 13; ++sfb)
        for (uint32_t w = 0; w < 3; ++w)
            b->width[n++] = short_widths[sfb];
    b->count = (uint8_t)n;
    for (uint32_t e = 0, sum = 0; e < n; ++e)
        b->end[e] = (uint16_t)(sum += b->width[e]);
    if (shorts) {
        b->region1 = (uint16_t)(3 * (short_widths[0] + short_widths[1] + short_widths[2]));
        b->region2 = 576;
    } else { // Region ends are long band ends; window switching implies 8 bands, then the rest.
        const uint32_t first = g->block_type ? 7 : g->region0, second = first + g->region1 + 1;
        b->region1 = b->end[first];
        b->region2 = g->block_type ? 576 : b->end[second < 21 ? second : 21];
    }
    uint32_t counts[4] = {6, 5, 5, 5}, slen[4] = {0}, preflag = g->preflag, c = g->scalefac_compress;
    if (!lsf) {
        slen[0] = slen[1] = kSlen[0][c];
        slen[2] = slen[3] = kSlen[1][c];
        if (shorts) {
            counts[0] = b->longs ? 17 : 18;
            counts[1] = 18;
            counts[2] = counts[3] = 0;
            slen[1] = slen[2];
        }
    } else { // MPEG-2: scalefac_compress is a mixed-radix number past one of six starts.
        static const uint16_t kStart[6] = {0, 400, 500, 0, 180, 244};
        static const uint8_t kRadix[6][3] = {{5, 4, 4}, {5, 4, 1}, {3, 1, 1},
                                             {6, 6, 1}, {4, 4, 1}, {3, 1, 1}};
        uint32_t table = intensity_right ? 3 : 0;
        c >>= intensity_right;
        while (table % 3 < 2 && c >= kStart[table + 1])
            ++table;
        c -= kStart[table];
        for (uint32_t p = 3; p; --p)
            slen[p] = c % kRadix[table][p - 1], c /= kRadix[table][p - 1];
        slen[0] = c;
        preflag = table == 2;
        for (uint32_t p = 0; p < 4; ++p)
            counts[p] = kLsfCounts[table][shorts ? (b->longs ? 2 : 1) : 0][p];
    }
    uint32_t k = 0;
    for (uint32_t p = 0; p < 4; ++p) {
        if (g->scfsi & (8 >> p)) {
            k += counts[p];
            continue;
        }
        for (uint32_t i = 0; i < counts[p]; ++i, ++k) {
            sf[k] = (uint8_t)take(r, slen[p]);
            limit[k] = (uint8_t)(lsf ? (1u << slen[p]) - 1 : 7);
        }
    }
    memset(sf + k, 0, n - k); // The last bands carry no scalefactor.
    const int32_t gain = g->global_gain - 210, shift = g->scalefac_scale ? 4 : 2;
    for (uint32_t e = 0; e < n; ++e) {
        int32_t q = gain;
        if (e < b->longs)
            q -= shift * (sf[e] + (preflag ? kPretab[e] : 0));
        else
            q -= 8 * g->subblock_gain[(e - b->longs) % 3] + shift * sf[e];
        b->scale[e] = quarter_power(q);
    }
}

static float pow43(uint32_t v) { // v^(4/3) beyond the table: v^2 y^2 for y Newton's inverse cube root
    const double d = v;
    uint64_t bits;
    memcpy(&bits, &d, 8);
    bits = 0x553ef0ff289dd796ull - bits / 3;
    double y;
    memcpy(&y, &bits, 8);
    for (uint32_t i = 0; i < 4; ++i)
        y *= (4 - d * y * y * y) * (1.0 / 3);
    return (float)(d * d * y * y);
}

static inline float with_sign(float magnitude, uint32_t sign) {
    uint32_t bits;
    memcpy(&bits, &magnitude, 4);
    bits ^= sign << 31;
    memcpy(&magnitude, &bits, 4);
    return magnitude;
}

// One Huffman-coded value's magnitude (with linbits) and sign, without
// data-dependent branches; c holds the bits after the codeword and advances
// past what the value used.
static inline float value(uint32_t v, uint32_t linbits, uint64_t* c, uint32_t* used) {
    if (v == 15 && linbits) {
        v += (uint32_t)(*c >> (64 - linbits));
        *c <<= linbits;
        *used += linbits;
    }
    const uint32_t nonzero = v != 0, sign = (uint32_t)(*c >> 63) & nonzero;
    *c <<= nonzero;
    *used += nonzero;
    return with_sign(v < 16 ? kPow43[v] : pow43(v), sign);
}

// Decodes the big values and count1 quadruples between at and end into x
// (zeroed), unscaled, and returns the end of the decoded lines. c caches
// `valid` bits from at; reads stop one pair or quadruple past end, inside the
// main data's padding.
static uint32_t lines(const uint8_t* data, uint32_t at, uint32_t end, const Mp3Granule* g, const Bands* b,
                      float* x) {
    uint32_t i = 0, valid = 0;
    uint64_t c = 0;
    const uint32_t big = g->big_values * 2u;
    for (uint32_t region = 0; region < 3; ++region) {
        uint32_t limit = region == 0 ? b->region1 : region == 1 ? b->region2 : 576;
        limit = limit < big ? limit : big;
        const uint32_t select = kTableSelect[g->table[region]], linbits = select >> 4,
                       need = 21 + 2 * linbits;
        if (!(select & 15)) { // Table 0: zeros without bits.
            i = i > limit ? i : limit;
            continue;
        }
        const int16_t* table = kHuffman + kHuffmanTables[(select & 15) - 1][0];
        const uint32_t root = kHuffmanTables[(select & 15) - 1][1];
        for (; i < limit; i += 2) {
            if (at > end)
                return i;
            if (valid < need) // Codeword, linbits and signs.
                c = peek(data, at), valid = 64 - (at & 7);
            int32_t e = table[c >> (64 - root)];
            uint32_t used = 0, bits = root;
            while (e < 0) {
                used += bits;
                bits = (uint32_t)-e & 15;
                e = table[((uint32_t)-e >> 4) + (uint32_t)(c << used >> (64 - bits))];
            }
            used += (uint32_t)e >> 8; // The codeword and its sign bits.
            const uint32_t vx = ((uint32_t)e >> 4) & 15, vy = (uint32_t)e & 15,
                           signs = (vx != 0) + (vy != 0);
            const uint64_t t = c << (used - signs);
            if (linbits) { // Linbits precede each sign.
                c = t;
                used -= signs;
                x[i] = value(vx, linbits, &c, &used);
                x[i + 1] = value(vy, linbits, &c, &used);
            } else {
                const uint32_t first = (uint32_t)(t >> 63), second = (uint32_t)(t >> 62) & 1;
                x[i] = with_sign(kPow43[vx], first & (vx != 0));
                x[i + 1] = with_sign(kPow43[vy], (vx ? second : first) & (vy != 0));
                c <<= used;
            }
            at += used;
            valid -= used;
        }
    }
    i = i > big ? i : big;
    while (i <= 572 && at < end) {
        if (valid < 10)
            c = peek(data, at), valid = 64 - (at & 7);
        uint32_t v = 15 - (uint32_t)(c >> 60), used = 4;
        if (!g->count1_table)
            v = kCount1[c >> 58] & 15, used = kCount1[c >> 58] >> 4;
        const uint32_t nonzero = (v >> 3) + (v >> 2 & 1) + (v >> 1 & 1) + (v & 1);
        used += g->count1_table ? nonzero : 0;
        if (at + used > end) // An overrunning quadruple is discarded (ISO reference).
            break;
        // The sign bits after the codeword, one per nonzero value in order.
        const uint32_t signs = (uint32_t)(c << (used - nonzero) >> 60);
        for (uint32_t k = 0, taken = 0; k < 4; ++k) {
            const uint32_t set = v >> (3 - k) & 1;
            x[i + k] = with_sign((float)set, (signs >> (3 - taken)) & set);
            taken += set;
        }
        c <<= used;
        at += used;
        valid -= used;
        i += 4;
    }
    return i;
}

// Huffman decoding and requantization: the decoded lines times their bands'
// scales, spread over a line array 8 at a time. Returns the end of the lines.
static uint32_t huffman(const uint8_t* data, uint32_t at, uint32_t end, const Mp3Granule* g, const Bands* b,
                        float* x) {
    const uint32_t count = lines(data, at, end, g, b, x);
    float scales[576 + 16];
    uint32_t i = 0;
    for (uint32_t e = 0; i < count; i = b->end[e++])
        for (uint32_t j = i; j < b->end[e]; j += 8)
            _mm256_storeu_ps(scales + j, splat(b->scale[e]));
    _mm256_storeu_ps(scales + i, _mm256_setzero_ps());
    for (i = 0; i < count; i += 8)
        _mm256_storeu_ps(x + i, _mm256_mul_ps(_mm256_loadu_ps(x + i), _mm256_loadu_ps(scales + i)));
    return count;
}

static void mid_side(float* l, float* r, uint32_t from, uint32_t to) {
    for (uint32_t i = from; i < to; ++i) {
        const float m = l[i], s = r[i];
        l[i] = (m + s) * 0.70710678f;
        r[i] = (m - s) * 0.70710678f;
    }
}

// Joint stereo on band-ordered lines. Intensity coding starts above the right
// channel's last nonzero band (per window in short bands); the band structure
// is the left channel's, positions are the right channel's scalefactors.
static void stereo(float* l, float* r, const Mp3Frame* f, const Bands* b, const uint8_t* positions,
                   const uint8_t* limits, uint32_t scale_bit, uint32_t end) {
    if (!f->intensity) {
        if (f->mid_side)
            mid_side(l, r, 0, end);
        return;
    }
    uint32_t long_start = 0, short_start[3] = {b->first_short, b->first_short, b->first_short}, at = 0;
    for (uint32_t e = 0; e < b->count; at += b->width[e++]) {
        uint32_t nonzero = 0;
        for (uint32_t i = at; i < at + b->width[e]; ++i)
            nonzero |= r[i] != 0;
        if (!nonzero)
            continue;
        if (e < b->longs)
            long_start = e + 1;
        else
            short_start[(e - b->longs) % 3] = b->first_short + (e - b->longs) / 3 + 1;
    }
    if (b->count > b->longs && short_start[0] + short_start[1] + short_start[2] > 3u * b->first_short)
        long_start = b->longs; // The short part decides; no intensity in the long part.
    at = 0;
    for (uint32_t e = 0; e < b->count; at += b->width[e++]) {
        const uint32_t sfb = e < b->longs ? e : b->first_short + (e - b->longs) / 3;
        const uint32_t from = e < b->longs ? long_start : short_start[(e - b->longs) % 3];
        uint32_t position = positions[e], limit = limits[e];
        if (e < b->longs ? b->longs == 22 && e == 21 : sfb == 12) {
            // The last band has no position: the band below's if that is intensity coded, else a default
            // (centre for MPEG-1, equal for MPEG-2).
            const uint32_t below = e - (e < b->longs ? 1 : 3), coded = sfb - 1 >= from;
            position = coded ? positions[below] : f->version == 3 ? 3 : 0;
            limit = coded ? limits[below] : 8;
        }
        if (sfb < from || position >= limit) {
            if (f->mid_side)
                mid_side(l, r, at, at + b->width[e]);
            continue;
        }
        float left, right;
        if (f->version == 3) {
            left = kIntensity[position];
            right = 1.0f - left;
        } else {
            const int32_t step = -(int32_t)(scale_bit + 1) * (int32_t)((position + 1) >> 1);
            left = position & 1 ? quarter_power(step) : 1.0f;
            right = position && !(position & 1) ? quarter_power(step) : 1.0f;
        }
        for (uint32_t i = at; i < at + b->width[e]; ++i) {
            const float v = l[i];
            l[i] = v * left;
            r[i] = v * right;
        }
    }
}

// Short bands from window-major to the IMDCT's subband order: per subband the
// three windows' six lines.
static void reorder(float* x, const uint8_t* widths, uint32_t first) {
    float t[576];
    uint32_t start = 0;
    for (uint32_t sfb = 0; sfb < first; ++sfb)
        start += widths[sfb];
    memcpy(t, x + 3 * start, (576 - 3 * start) * sizeof(float));
    const float* source = t;
    for (uint32_t sfb = first; sfb < 13; start += widths[sfb++])
        for (uint32_t w = 0; w < 3; ++w)
            for (uint32_t j = 0; j < widths[sfb]; ++j) {
                const uint32_t line = start + j;
                x[line / 6 * 18 + w * 6 + line % 6] = *source++;
            }
}

static void antialias(float* x, uint32_t boundaries) {
    for (uint32_t sb = 1; sb <= boundaries; ++sb) {
        float *up = x + 18 * sb - 1, *down = x + 18 * sb;
        for (uint32_t i = 0; i < 8; ++i) {
            const float u = up[-(int32_t)i], d = down[i];
            up[-(int32_t)i] = u * kAntialias[0][i] - d * kAntialias[1][i];
            down[i] = d * kAntialias[0][i] + u * kAntialias[1][i];
        }
    }
}

static inline void transpose(V* r) {
    const V t0 = _mm256_unpacklo_ps(r[0], r[1]), t1 = _mm256_unpackhi_ps(r[0], r[1]);
    const V t2 = _mm256_unpacklo_ps(r[2], r[3]), t3 = _mm256_unpackhi_ps(r[2], r[3]);
    const V t4 = _mm256_unpacklo_ps(r[4], r[5]), t5 = _mm256_unpackhi_ps(r[4], r[5]);
    const V t6 = _mm256_unpacklo_ps(r[6], r[7]), t7 = _mm256_unpackhi_ps(r[6], r[7]);
    const V u0 = _mm256_shuffle_ps(t0, t2, 0x44), u1 = _mm256_shuffle_ps(t0, t2, 0xee);
    const V u2 = _mm256_shuffle_ps(t1, t3, 0x44), u3 = _mm256_shuffle_ps(t1, t3, 0xee);
    const V u4 = _mm256_shuffle_ps(t4, t6, 0x44), u5 = _mm256_shuffle_ps(t4, t6, 0xee);
    const V u6 = _mm256_shuffle_ps(t5, t7, 0x44), u7 = _mm256_shuffle_ps(t5, t7, 0xee);
    r[0] = _mm256_permute2f128_ps(u0, u4, 0x20);
    r[1] = _mm256_permute2f128_ps(u1, u5, 0x20);
    r[2] = _mm256_permute2f128_ps(u2, u6, 0x20);
    r[3] = _mm256_permute2f128_ps(u3, u7, 0x20);
    r[4] = _mm256_permute2f128_ps(u0, u4, 0x31);
    r[5] = _mm256_permute2f128_ps(u1, u5, 0x31);
    r[6] = _mm256_permute2f128_ps(u2, u6, 0x31);
    r[7] = _mm256_permute2f128_ps(u3, u7, 0x31);
}

// DCT-III of 9 (out[n] = sum y[j] cos(pi j (2n + 1) / 18)), even and odd terms
// shared between n and 8 - n.
static inline void dct3_9(const V* y, V* out) {
    for (uint32_t n = 0; n < 4; ++n) {
        V even = y[0], odd = _mm256_mul_ps(y[1], splat(kCos9[0][n]));
        for (uint32_t j = 2; j < 9; j += 2)
            even = _mm256_add_ps(even, _mm256_mul_ps(y[j], splat(kCos9[j - 1][n])));
        for (uint32_t j = 3; j < 9; j += 2)
            odd = _mm256_add_ps(odd, _mm256_mul_ps(y[j], splat(kCos9[j - 1][n])));
        out[n] = _mm256_add_ps(even, odd);
        out[8 - n] = _mm256_sub_ps(even, odd);
    }
    out[4] = _mm256_add_ps(_mm256_sub_ps(_mm256_add_ps(_mm256_sub_ps(y[0], y[2]), y[4]), y[6]), y[8]);
}

// DCT-IV of 18, the 36-point IMDCT's kernel: summing adjacent inputs turns a
// DCT-IV into a DCT-III, whose odd half is a DCT-IV of 9 again.
static inline void dct4_18(const V* x, V* z) {
    V even[9], odd[9], e[9], o[9];
    even[0] = x[0];
    for (uint32_t j = 1; j < 9; ++j)
        even[j] = _mm256_add_ps(x[2 * j], x[2 * j - 1]);
    for (uint32_t j = 0; j < 9; ++j)
        odd[j] = _mm256_add_ps(x[2 * j + 1], x[2 * j]);
    for (uint32_t j = 8; j; --j)
        odd[j] = _mm256_add_ps(odd[j], odd[j - 1]);
    dct3_9(even, e);
    dct3_9(odd, o);
    for (uint32_t n = 0; n < 9; ++n) {
        const V scaled = _mm256_mul_ps(o[n], splat(kTwiddle9[n]));
        z[n] = _mm256_mul_ps(_mm256_add_ps(e[n], scaled), splat(kTwiddle18[n]));
        z[17 - n] = _mm256_mul_ps(_mm256_sub_ps(e[n], scaled), splat(kTwiddle18[17 - n]));
    }
}

// The 12-point IMDCT of window w's six lines: z[0..2] = Z[3..5], z[3..8] =
// -Z[5..0], z[9..11] = -Z[0..2] for Z the DCT-IV of 6.
static void imdct12(const V* x, V* z) {
    V d[6];
    for (uint32_t n = 0; n < 6; ++n) {
        d[n] = _mm256_mul_ps(x[0], splat(kCos6[n][0]));
        for (uint32_t k = 1; k < 6; ++k)
            d[n] = _mm256_add_ps(d[n], _mm256_mul_ps(x[k], splat(kCos6[n][k])));
    }
    for (uint32_t i = 0; i < 3; ++i) {
        z[i] = d[3 + i];
        z[9 + i] = negate(d[i]);
    }
    for (uint32_t i = 0; i < 6; ++i)
        z[3 + i] = negate(d[5 - i]);
}

// Hybrid synthesis of 8 subbands (lanes): IMDCT, windowing, overlap-add with
// the previous granule and frequency inversion. The first `split` lanes are a
// mixed block's long part; the others use `shorts` or the long `window`.
// tail[j * 32] keeps 12 terms per subband from which the next granule rebuilds
// this one's windowed second half: long blocks the 9 distinct IMDCT outputs,
// short ones the second window's tail and the third window's 6 distinct values.
typedef struct Kind {
    uint32_t split, shorts;
    const float* window; // Long first half, or the tail weights for the previous granule.
} Kind;
static void imdct(const float* in, float* tail, float* out, Kind now, Kind before, int active) {
    V y[18], keep[12];
    const V zero = _mm256_setzero_ps(), split = lanes(now.split);
    if (active) {
        V x[24], z[18];
        for (uint32_t c = 0; c < 3; ++c) {
            for (uint32_t l = 0; l < 8; ++l)
                x[8 * c + l] = _mm256_loadu_ps(in + l * 18 + 8 * c);
            transpose(x + 8 * c);
        }
        if (!now.shorts || now.split) {
            dct4_18(x, z);
            for (uint32_t n = 0; n < 18; ++n) {
                const V w = _mm256_blendv_ps(splat(now.window[n]), splat(kLongWindow[0][n]), split);
                y[n] = _mm256_mul_ps(w, z[n < 9 ? 9 + n : 26 - n]);
            }
            for (uint32_t m = 0; m < 9; ++m)
                keep[m] = z[8 - m];
            keep[9] = keep[10] = keep[11] = zero;
        }
        if (now.shorts) {
            V w0[12], w1[12], w2[12];
            imdct12(x, w0);
            imdct12(x + 6, w1);
            imdct12(x + 12, w2);
            V sy[18], sk[12];
            for (uint32_t i = 0; i < 6; ++i) {
                sy[i] = zero;
                sy[6 + i] = _mm256_mul_ps(w0[i], splat(kShortWindow[i]));
                sy[12 + i] = _mm256_add_ps(_mm256_mul_ps(w0[6 + i], splat(kShortWindow[6 + i])),
                                           _mm256_mul_ps(w1[i], splat(kShortWindow[i])));
                sk[i] = w1[6 + i];
            }
            for (uint32_t i = 0; i < 3; ++i) {
                sk[6 + i] = w2[6 + i];
                sk[9 + i] = w2[i];
            }
            for (uint32_t n = 0; n < 18; ++n)
                y[n] = now.split ? _mm256_blendv_ps(sy[n], y[n], split) : sy[n];
            for (uint32_t m = 0; m < 12; ++m)
                keep[m] = now.split ? _mm256_blendv_ps(sk[m], keep[m], split) : sk[m];
        }
    } else {
        for (uint32_t n = 0; n < 18; ++n)
            y[n] = zero;
        for (uint32_t m = 0; m < 12; ++m)
            keep[m] = zero;
    }
    const V low = lanes(before.split);
    for (uint32_t n = 0; n < 18; ++n) {
        const V weight = _mm256_blendv_ps(splat(before.window[n]), splat(kTail[0][n]), low);
        y[n] =
            _mm256_add_ps(y[n], _mm256_mul_ps(weight, _mm256_loadu_ps(tail + (n < 9 ? n : 17 - n) * 32)));
        if (n < 6 && before.shorts) {
            const V weight3 = _mm256_blendv_ps(splat(kTailShort[n]), zero, low);
            y[n] = _mm256_add_ps(
                y[n], _mm256_mul_ps(weight3, _mm256_loadu_ps(tail + (n < 3 ? 9 + n : 14 - n) * 32)));
        }
        if (n & 1)
            y[n] = _mm256_xor_ps(y[n], _mm256_loadu_ps(kOddLanes));
    }
    for (uint32_t m = 0; m < 12; ++m)
        _mm256_storeu_ps(tail + m * 32, keep[m]);
    for (uint32_t c = 0; c < 3; ++c) {
        V r[8];
        for (uint32_t l = 0; l < 8; ++l)
            r[l] = 8 * c + l < 18 ? y[8 * c + l] : zero;
        transpose(r);
        for (uint32_t l = 0; l < 8; ++l) {
            if (c < 2) {
                _mm256_storeu_ps(out + l * kSlots + 8 * c, r[l]);
            } else {
                float last[8];
                _mm256_storeu_ps(last, r[l]);
                memcpy(out + l * kSlots + 16, last, 2 * sizeof(float));
            }
        }
    }
}

// Reorder, alias reduction and IMDCT of one granule channel into 18 slots of
// the 32 subband rows at out.
static void hybrid(float* x, const Mp3Granule* g, uint32_t rate_index, float* overlap, uint8_t* previous,
                   float* out) {
    const uint32_t shorts = g->block_type == 2, longs = rate_index == 8 ? 4 : 2;
    if (shorts)
        reorder(x, kShortWidths[rate_index], g->mixed ? 3 : 0);
    antialias(x, shorts ? (g->mixed ? longs - 1 : 0) : 31);
    uint32_t top = 576;
    while (top && x[top - 1] == 0)
        --top;
    const uint32_t before_type = *previous & 3, before_mixed = *previous >> 2;
    for (uint32_t group = 0; group < 4; ++group) {
        const Kind now = {group || !g->mixed ? 0 : longs, shorts, kLongWindow[g->block_type == 3]};
        const Kind before = {group || !before_mixed ? 0 : longs, before_type == 2,
                             kTail[before_type == 2 ? 2 : before_type == 1]};
        imdct(x + 144 * group, overlap + 8 * group, out + 8 * group * kSlots, now, before,
              144 * group < top);
    }
    *previous = (uint8_t)(g->block_type | g->mixed << 2);
}

// DCT-II of 4 and 8 vectors in registers; twiddles as in dct.
static inline void dct4(V* a, const float* twiddle) {
    const V p0 = _mm256_add_ps(a[0], a[3]), p1 = _mm256_add_ps(a[1], a[2]);
    const V q0 = _mm256_mul_ps(_mm256_sub_ps(a[0], a[3]), splat(twiddle[0]));
    const V q1 = _mm256_mul_ps(_mm256_sub_ps(a[1], a[2]), splat(twiddle[1]));
    const V q = _mm256_mul_ps(_mm256_sub_ps(q0, q1), splat(twiddle[2]));
    a[0] = _mm256_add_ps(p0, p1);
    a[1] = _mm256_add_ps(_mm256_add_ps(q0, q1), q);
    a[2] = _mm256_mul_ps(_mm256_sub_ps(p0, p1), splat(twiddle[2]));
    a[3] = q;
}
static inline void dct8(V* x, const float* twiddle) {
    V a[4], b[4];
    for (uint32_t k = 0; k < 4; ++k) {
        a[k] = _mm256_add_ps(x[k], x[7 - k]);
        b[k] = _mm256_mul_ps(_mm256_sub_ps(x[k], x[7 - k]), splat(twiddle[k]));
    }
    dct4(a, twiddle + 4);
    dct4(b, twiddle + 4);
    for (uint32_t m = 0; m < 4; ++m) {
        x[2 * m] = a[m];
        x[2 * m + 1] = m < 3 ? _mm256_add_ps(b[m], b[m + 1]) : b[3];
    }
}

// In-place DCT-II of n time-slot vectors (sum x[k] cos(pi i (2k + 1) / 2n)):
// halves of sums and of differences scaled by 1 / (2 cos(pi (2k + 1) / 2n)).
static void dct(V* x, V* t, uint32_t n, const float* twiddle) {
    if (n == 8) {
        dct8(x, twiddle);
        return;
    }
    const uint32_t h = n / 2;
    for (uint32_t k = 0; k < h; ++k) {
        t[k] = _mm256_add_ps(x[k], x[n - 1 - k]);
        t[h + k] = _mm256_mul_ps(_mm256_sub_ps(x[k], x[n - 1 - k]), splat(twiddle[k]));
    }
    dct(t, x, h, twiddle + h);
    dct(t + h, x + h, h, twiddle + h);
    for (uint32_t m = 0; m < h; ++m) {
        x[2 * m] = t[m];
        x[2 * m + 1] = m + 1 < h ? _mm256_add_ps(t[h + m], t[h + m + 1]) : t[h + m];
    }
}

// 15 floats as two overlapping 8-lane copies.
static inline void copy15(float* to, const float* from) {
    const V head = _mm256_loadu_ps(from), tail = _mm256_loadu_ps(from + 7);
    _mm256_storeu_ps(to, head);
    _mm256_storeu_ps(to + 7, tail);
}

// Polyphase synthesis of one channel's slots (rows of 32 subbands at in) into
// interleaved PCM. rows holds 15 slots of history, then this frame's DCTs.
static void synthesize(const float* in, uint32_t slots, float* history, float* rows, float* pcm,
                       uint32_t channels, uint32_t channel) {
    const uint32_t groups = (slots + 7) / 8;
    const V zero = _mm256_setzero_ps();
    for (uint32_t k = 0; k < 32; ++k)
        copy15(rows + k * kRows, history + k * 15);
    for (uint32_t group = 0; group < groups; ++group) {
        V v[32], t[32];
        for (uint32_t sb = 0; sb < 32; ++sb)
            v[sb] = _mm256_loadu_ps(in + sb * kSlots + 8 * group);
        dct(v, t, 32, kDctTwiddle);
        for (uint32_t k = 0; k < 32; ++k)
            _mm256_storeu_ps(rows + k * kRows + 15 + 8 * group, v[k]);
    }
    for (uint32_t group = 0; group < groups; ++group) {
        // Output j of 8 slots: the window over the 16 latest slots' DCT rows
        // 16 + j (even ages) and 16 - j (odd); 32 - j uses the same rows.
        const float* base = rows + 15 + 8 * group;
        V o[32];
        for (uint32_t j = 0; j < 16; ++j) {
            const float *even = base + (16 + j) * kRows, *odd = base + (16 - j) * kRows - 1;
            V first = zero, second = zero;
            for (uint32_t i = 0; i < 8; ++i) {
                const V e = _mm256_loadu_ps(even - 2 * i), d = _mm256_loadu_ps(odd - 2 * i);
                first = _mm256_add_ps(first, _mm256_add_ps(_mm256_mul_ps(e, splat(kSynthesis[j][i][0])),
                                                           _mm256_mul_ps(d, splat(kSynthesis[j][i][1]))));
                second =
                    _mm256_add_ps(second, _mm256_sub_ps(_mm256_mul_ps(d, splat(kSynthesis[j][7 - i][0])),
                                                        _mm256_mul_ps(e, splat(kSynthesis[j][7 - i][1]))));
            }
            o[j] = first;
            if (j)
                o[32 - j] = second;
        }
        o[16] = zero;
        for (uint32_t i = 0; i < 8; ++i)
            o[16] = _mm256_add_ps(
                o[16], _mm256_mul_ps(_mm256_loadu_ps(base - 1 - 2 * i), splat(kSynthesisMiddle[i])));
        const uint32_t count = slots - 8 * group < 8 ? slots - 8 * group : 8;
        // Stereo: each channel's samples, duplicated, blend into their lanes.
        const V lanes_of_channel = channel ? _mm256_loadu_ps(kOddLanes) : _mm256_loadu_ps(kOddLanes + 1);
        for (uint32_t block = 0; block < 4; ++block) {
            transpose(o + 8 * block);
            for (uint32_t t = 0; t < count; ++t) {
                float* p = pcm + ((8 * group + t) * 32 + 8 * block) * channels;
                const V r = o[8 * block + t], low = _mm256_unpacklo_ps(r, r),
                        high = _mm256_unpackhi_ps(r, r);
                if (channels == 1) {
                    _mm256_storeu_ps(p, r);
                    continue;
                }
                _mm256_storeu_ps(p, _mm256_blendv_ps(_mm256_loadu_ps(p),
                                                     _mm256_permute2f128_ps(low, high, 0x20),
                                                     lanes_of_channel));
                _mm256_storeu_ps(p + 8, _mm256_blendv_ps(_mm256_loadu_ps(p + 8),
                                                         _mm256_permute2f128_ps(low, high, 0x31),
                                                         lanes_of_channel));
            }
        }
    }
    for (uint32_t k = 0; k < 32; ++k)
        copy15(history + k * 15, rows + k * kRows + slots);
}

uint32_t mp3_frame_decode(Mp3DecoderState* s, const uint8_t* data, const Mp3Frame* f, float* pcm) {
    // Main data: the reservoir's last main_data_begin bytes, this frame's, and
    // zeros for the Huffman decoder's bounded overrun.
    uint8_t main[511 + 1441 + 64];
    const uint32_t have = s->reservoir_bytes, ready = f->main_data_begin <= have;
    const uint32_t kept = ready ? f->main_data_begin : have, total = kept + f->main_bytes;
    memcpy(main, s->reservoir + have - kept, kept);
    memcpy(main + kept, data + f->bytes - f->main_bytes, f->main_bytes);
    memset(main + total, 0, 64);
    uint32_t consumed = 0;
    if (ready) {
        const uint32_t channels = f->channels, granules = f->version == 3 ? 2 : 1, slots = 18 * granules;
        union {
            float lines[2][576 + 8]; // + 8: the IMDCT's last transposed loads
            float rows[32 * kRows];
        } work;
        float subbands[2][32 * kSlots];
        uint8_t sf[2][40] = {{0}}, limits[2][40] = {{0}};
        Bands bands[2];
        Reader r = {main, 0};
        for (uint32_t gr = 0; gr < granules; ++gr) {
            uint32_t ends[2] = {0, 0};
            for (uint32_t ch = 0; ch < channels; ++ch) {
                const Mp3Granule* g = &f->granules[gr * channels + ch];
                const uint32_t end = r.at + g->part2_3_bits;
                memset(work.lines[ch], 0, sizeof(work.lines[ch]));
                scalefactors(&r, f, g, f->intensity && ch, sf[ch], limits[ch], &bands[ch]);
                ends[ch] = huffman(main, r.at, end, g, &bands[ch], work.lines[ch]);
                r.at = end;
            }
            if (channels == 2)
                stereo(work.lines[0], work.lines[1], f, &bands[0], sf[1], limits[1],
                       f->granules[gr * 2 + 1].scalefac_compress & 1,
                       ends[0] > ends[1] ? ends[0] : ends[1]);
            for (uint32_t ch = 0; ch < channels; ++ch)
                hybrid(work.lines[ch], &f->granules[gr * channels + ch], f->rate_index,
                       &s->overlap[ch][0][0], &s->previous_block[ch], subbands[ch] + 18 * gr);
        }
        for (uint32_t ch = 0; ch < channels; ++ch) {
            for (uint32_t sb = 0; sb < 32; ++sb)
                memset(subbands[ch] + sb * kSlots + slots, 0, (kSlots - slots) * sizeof(float));
            synthesize(subbands[ch], slots, &s->history[ch][0][0], work.rows, pcm, channels, ch);
        }
        consumed = (r.at + 7) / 8;
    }
    // Keep up to 511 bytes after the consumed main data for later frames.
    uint32_t remains = total - consumed;
    remains = remains < 511 ? remains : 511;
    memcpy(s->reservoir, main + total - remains, remains);
    s->reservoir_bytes = (uint16_t)remains;
    return ready ? f->samples : 0;
}
